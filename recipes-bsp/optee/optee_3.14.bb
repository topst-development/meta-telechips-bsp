require optee-common.inc

COMPATIBLE_MACHINE = "(tcc897x|tcc803x|tcc805x)"
OPTEE_BRANCH = "v3.14"
SRCREV = "${AUTOREV}"
