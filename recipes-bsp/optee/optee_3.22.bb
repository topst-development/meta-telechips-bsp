require optee-common.inc

COMPATIBLE_MACHINE = "(tcc803x|tcc805x|tcc807x|tcc750x)"
OPTEE_BRANCH = "v3.22"
SRCREV = "${AUTOREV}"
