require optee-common.inc

COMPATIBLE_MACHINE = "(tcc897x|tcc802x|tcc803x|tcc805x)"
OPTEE_BRANCH = "v3.12"
SRCREV = "${AUTOREV}"
