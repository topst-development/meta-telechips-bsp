require optee-common.inc

COMPATIBLE_MACHINE = "(tcc897x|tcc803x|tcc805x|tcc750x|tcc807x)"
OPTEE_BRANCH = "v3.18"
SRCREV = "${AUTOREV}"
